File: Motherboard/motherboard_2022_2023/buck.kicad_sch (KiCad schematic)
At the start: 11 parts

Commit message: Add 2 pyro channels
Parts:
- C1, C2, C3, C4, C5: renamed from C?; footprint (none) -> Capacitor_SMD:C_0603_1608Metric
- L1: renamed from L?; footprint (none) -> Inductor_SMD:L_Coilcraft_XAL60xx_6.36x6.56mm
- R1, R2, R3, R4: renamed from R?; footprint (none) -> Resistor_SMD:R_0603_1608Metric
- gave numbers to parts that had none: 1
Changed lines of the file:
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@@
   (symbol (lib_id "Device:R") (at 194.31 48.26 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R?" (id 0) (at 196.85 46.9899 0)
+    (property "Reference" "R4" (id 0) (at 196.85 46.9899 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 192.532 48.26 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (id 2) (at 192.532 48.26 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "pspice:C") (at 95.25 44.45 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "C?" (id 0) (at 100.33 43.1799 0)
+    (property "Reference" "C2" (id 0) (at 100.33 43.1799 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 95.25 44.45 0)
+    (property "Footprint" "Capacitor_SMD:C_0603_1608Metric" (id 2) (at 95.25 44.45 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Device:R") (at 123.19 41.91 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R?" (id 0) (at 125.73 40.6399 0)
+    (property "Reference" "R1" (id 0) (at 125.73 40.6399 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 121.412 41.91 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (id 2) (at 121.412 41.91 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "pspice:INDUCTOR") (at 179.07 30.48 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "L?" (id 0) (at 179.07 24.13 0))
+    (property "Reference" "L1" (id 0) (at 179.07 24.13 0))
     (property "Value" "1.8uH 9.6mOhm" (id 1) (at 179.07 26.67 0))
-    (property "Footprint" "" (id 2) (at 179.07 30.48 0)
+    (property "Footprint" "Inductor_SMD:L_Coilcraft_XAL60xx_6.36x6.56mm" (id 2) (at 179.07 30.48 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "pspice:C") (at 81.28 44.45 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "C?" (id 0) (at 86.36 43.1799 0)
+    (property "Reference" "C1" (id 0) (at 86.36 43.1799 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 81.28 44.45 0)
+    (property "Footprint" "Capacitor_SMD:C_0603_1608Metric" (id 2) (at 81.28 44.45 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "pspice:C") (at 238.76 44.45 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "C?" (id 0) (at 243.84 43.1799 0)
+    (property "Reference" "C5" (id 0) (at 243.84 43.1799 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 238.76 44.45 0)
+    (property "Footprint" "Capacitor_SMD:C_0603_1608Metric" (id 2) (at 238.76 44.45 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Device:R") (at 123.19 54.61 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R?" (id 0) (at 125.73 53.3399 0)
+    (property "Reference" "R2" (id 0) (at 125.73 53.3399 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 121.412 54.61 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (id 2) (at 121.412 54.61 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Device:C_Small") (at 204.47 35.56 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "C?" (id 0) (at 207.01 34.2962 0)
+    (property "Reference" "C3" (id 0) (at 207.01 34.2962 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 204.47 35.56 0)
+    (property "Footprint" "Capacitor_SMD:C_0603_1608Metric" (id 2) (at 204.47 35.56 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Device:R") (at 194.31 35.56 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R?" (id 0) (at 196.85 34.2899 0)
+    (property "Reference" "R3" (id 0) (at 196.85 34.2899 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 192.532 35.56 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (id 2) (at 192.532 35.56 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "custom_symbols:TPS56424x") (at 157.48 33.02 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U?" (id 0) (at 157.48 22.86 0))
+    (property "Reference" "U3" (id 0) (at 157.48 22.86 0))
     (property "Value" "TPS56424x" (id 1) (at 157.48 25.4 0))
     (property "Footprint" "Package_TO_SOT_SMD:SOT-563" (id 2) (at 158.75 39.37 0)
@@
   (symbol (lib_id "power:+5V") (at 252.73 30.48 270) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR?" (id 0) (at 248.92 30.48 0)
+    (property "Reference" "#PWR0114" (id 0) (at 248.92 30.48 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "pspice:C") (at 222.25 44.45 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "C?" (id 0) (at 227.33 43.1799 0)
+    (property "Reference" "C4" (id 0) (at 227.33 43.1799 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "" (id 2) (at 222.25 44.45 0)
+    (property "Footprint" "Capacitor_SMD:C_0603_1608Metric" (id 2) (at 222.25 44.45 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "power:GND") (at 156.21 62.23 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR?" (id 0) (at 156.21 68.58 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Reference" "#PWR0113" (id 0) (at 156.21 68.58 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Preliminary PCB layout
Other:
- note added: "NOTE: WE'RE GOING TO USE A DIFFERENT CHIP"
Changed lines of the file:
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@@
     (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (text "NOTE: WE'RE GOING TO USE A DIFFERENT CHIP" (at 137.16 20.32 0)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
   )
   (hierarchical_label "V_BAT" (shape input) (at 46.99 30.48 180)

Commit message: Added SDA/SCL & Document Titles
Parts:
- renumbered R1 to R3, R2 to R4, R3 to R5, R4 to R6, U3 to U5
Other:
- note added: "NOTE: BUCK CONVERTER OUT OF DATE NEW PART NUMBER NEEDED."
- note removed: "NOTE: WE'RE GOING TO USE A DIFFERENT CHIP"
Changed lines of the file:
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@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (text "NOTE: WE'RE GOING TO USE A DIFFERENT CHIP" (at 137.16 20.32 0)
+  (text "NOTE: BUCK CONVERTER OUT OF DATE\nNEW PART NUMBER NEEDED."
+    (at 137.16 20.32 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
   (symbol (lib_id "Device:R") (at 194.31 48.26 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R4" (id 0) (at 196.85 46.9899 0)
+    (property "Reference" "R6" (id 0) (at 196.85 46.9899 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "Device:R") (at 123.19 41.91 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R1" (id 0) (at 125.73 40.6399 0)
+    (property "Reference" "R3" (id 0) (at 125.73 40.6399 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "Device:R") (at 123.19 54.61 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R2" (id 0) (at 125.73 53.3399 0)
+    (property "Reference" "R4" (id 0) (at 125.73 53.3399 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "Device:R") (at 194.31 35.56 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "R3" (id 0) (at 196.85 34.2899 0)
+    (property "Reference" "R5" (id 0) (at 196.85 34.2899 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "custom_symbols:TPS56424x") (at 157.48 33.02 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U3" (id 0) (at 157.48 22.86 0))
+    (property "Reference" "U5" (id 0) (at 157.48 22.86 0))
     (property "Value" "TPS56424x" (id 1) (at 157.48 25.4 0))
     (property "Footprint" "Package_TO_SOT_SMD:SOT-563" (id 2) (at 158.75 39.37 0)
@@
   (symbol (lib_id "power:+5V") (at 252.73 30.48 270) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR0114" (id 0) (at 248.92 30.48 0)
+    (property "Reference" "#PWR021" (id 0) (at 248.92 30.48 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "power:GND") (at 156.21 62.23 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR0113" (id 0) (at 156.21 68.58 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Reference" "#PWR020" (id 0) (at 156.21 68.58 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Updated Text
Other:
- note removed: "NOTE: BUCK CONVERTER OUT OF DATE NEW PART NUMBER NEEDED."
Changed lines of the file:
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@@
     (stroke (width 0) (type default) (color 0 0 0 0))
-  )
-  (text "NOTE: BUCK CONVERTER OUT OF DATE\nNEW PART NUMBER NEEDED."
-    (at 137.16 20.32 0)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
   )
   (hierarchical_label "V_BAT" (shape input) (at 46.99 30.48 180)

Commit message: Add power-up button
Parts:
- added SW1: SW_Push, Button_Switch_THT:SW_PUSH_6mm, symbol Switch:SW_Push
Connections:
- net V_BAT: now also SW1.1; no longer R3.1
- net EN: now reaches R3.2, R4.1, U5.5 (EN)
- new net: R3.1, SW1.2
Changed lines of the file:
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@@
   (junction (at 123.19 59.69) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 106.68 30.48) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 222.25 59.69) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 81.28 30.48) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 123.19 30.48) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 95.25 59.69) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 194.31 59.69) (diameter 0) (color 0 0 0 0)
   )
+  (wire (pts (xy 106.68 36.83) (xy 106.68 30.48))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 123.19 48.26) (xy 123.19 50.8))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 106.68 30.48) (xy 147.32 30.48))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 222.25 59.69) (xy 194.31 59.69))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 123.19 30.48) (xy 147.32 30.48))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 81.28 59.69) (xy 95.25 59.69))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 109.22 36.83) (xy 106.68 36.83))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 116.84 48.26) (xy 123.19 48.26))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 158.75 40.64) (xy 158.75 44.45))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 95.25 30.48) (xy 123.19 30.48))
+  (wire (pts (xy 95.25 30.48) (xy 106.68 30.48))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 123.19 36.83) (xy 123.19 38.1))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 156.21 59.69) (xy 123.19 59.69))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 119.38 36.83) (xy 123.19 36.83))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 238.76 30.48) (xy 238.76 38.1))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
   )
   (wire (pts (xy 181.61 35.56) (xy 181.61 41.91))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
-  (wire (pts (xy 123.19 30.48) (xy 123.19 38.1))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     )
   )
+  (hierarchical_label "EN" (shape input) (at 116.84 48.26 180)
+    (effects (font (size 1.27 1.27)) (justify right))
+  )
   (hierarchical_label "V_BAT" (shape input) (at 46.99 30.48 180)
     (effects (font (size 1.27 1.27)) (justify right))
@@
     (pin "6")
   )
+  (symbol (lib_id "Switch:SW_Push") (at 114.3 36.83 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "SW1" (id 0) (at 114.3 39.37 0))
+    (property "Value" "SW_Push" (id 1) (at 114.3 41.91 0))
+    (property "Footprint" "Button_Switch_THT:SW_PUSH_6mm" (id 2) (at 114.3 31.75 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 114.3 31.75 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+  )
   (symbol (lib_id "power:+5V") (at 252.73 30.48 270) (unit 1)

Commit message: Organize schematics
Connections:
- net V_BAT renamed +BATT
Other:
- moved on the sheet: C1, C2, C3, C4, C5, L1, R3, R4, R5, R6, SW1, U5
