# Repository Rose-Rocketry/NASA-USLI-2023-Electrical-Payload

File README.md:

# NASA-USLI-2023-Electrical-Payload

Welcome!

This repository is still in progress and houses the majority of the camera integration/functionality code for the NASA USLI 2023 Competition

Action items as of 9/25/2022:
- Add modular methods so other parts of the program can be run (i.e. "img2BW" "applySobel")
- Figure out how to do command line prompting to run the program so RF payload can use our program
- Prompt program to run with "[Radio Callsign] B2 A1 C3 D4 ..."
- Pick out and purchase microcontroller and antenna design
- Integrate camera to a microcontroller and upload code to microcontroller to run on boot (similar to systemctl)
- Have RF transmissions dictate the microcontroller operations of when to take pictures and apply filters (to be decided by RF Payload subsystem)
- Build antenna to send RF transmissions
- House camera payload in chassis to be determined by Mechanical Payload Team

Google Jamboard for Camera Payload: https://jamboard.google.com/d/17pDWzvR5QUZo6pmwbOdQxkDinwWt7RJfm15y4S94SMs/viewer?f=0

## KiCad design Motherboard/motherboard_2022_2023/motherboard_2022_2023.kicad_pcb

Parts:
BZ1: Buzzer; CPI-1375-80T
C13: 100n; C_0603_1608Metric
C14: 10n; C_0603_1608Metric
D3, D5: RED; LED_0603_1608Metric
D4: LED_RGBA; LED_RGB_5050-6
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: POWER; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J2: Raspberry_Pi_2_3; PI_Zero
J3: IO Expansion; PinHeader_2x04_P2.54mm_Horizontal
J4: STEMMA QT; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J6: SHUTDOWN; PinHeader_1x03_P2.54mm_Horizontal
JP3, JP4, JP5, JP6, JP7, JP8: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP9: PYRO_V; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm
R1, R2: 10k; R_0603_1608Metric
R13, R20: 68; R_0603_1608Metric
R18, R19: 15; R_0603_1608Metric
R21: 1k; R_0603_1608Metric
S0, S1, S2, S3, S4, S5, S6, S8, S9, S10: Servo Port; PinHeader_1x03_P2.54mm_Horizontal
U1: XBee_THT; XBee-THT
U3: PCA9685PW; TSSOP-28_4.4x9.7mm_P0.65mm

Connections:
+3V3: C13.2, C14.2, D4.4 (BA), D4.5 (GA), D4.6 (RA), J2.1 (3V3), J2.17 (3V3), J3.7, J3.8, J4.2, R1.2, R2.2, U1.1 (VCC), U3.1 (A0), U3.3 (A2), U3.5 (A4), U3.28 (VDD); also elsewhere on the board
+5V: J2.2 (5V), J2.4 (5V), JP9.1 (A), R21.1, S0.2, S1.2, S2.2, S3.2, S4.2, S5.2, S6.2, S8.2, S9.2, S10.2; also elsewhere on the board
+BATT: J1.2, JP9.3 (B); also elsewhere on the board
/Buzzer: BZ1.1 (-), J2.12 (GPIO18/PWM0)
/GPIO_1: J2.23 (SCLK0/GPIO11), J3.6
/GPIO_2: J2.29 (GCLK1/GPIO5), J3.5
/GPIO_3: J2.31 (GCLK2/GPIO6), J3.3
/GPIO_4: J2.33 (PWM1/GPIO13), J3.4
/LED_B: R20.1, U3.18 (LED11)
/LED_G: R19.1, U3.19 (LED12)
/LED_R: R18.1, U3.20 (LED13)
/MCP_CS: J2.36 (GPIO16); also elsewhere on the board
/MISO: J2.35 (GPIO19/MISO1); also elsewhere on the board
/MOSI: J2.38 (GPIO20/MOSI1); also elsewhere on the board
/PWM_0: S0.3, U3.6 (LED0)
/PWM_1: S1.3, U3.7 (LED1)
/PWM_2: S2.3, U3.8 (LED2)
/PWM_3: S3.3, U3.9 (LED3)
/PWM_4: S4.3, U3.10 (LED4)
/PWM_5: S5.3, U3.11 (LED5)
/PWM_6: S6.3, U3.12 (LED6)
/PWM_7: S8.3, U3.15 (LED8)
/PWM_8: S9.3, U3.16 (LED9)
/PWM_9: S10.3, U3.17 (LED10)
/PWR_EN: J2.32 (PWM0/GPIO12); also elsewhere on the board
/PYRO_A: U3.21 (LED14); also elsewhere on the board
/PYRO_A_SENSE: J2.26 (~CE1/GPIO7); also elsewhere on the board
/PYRO_B: U3.22 (LED15); also elsewhere on the board
/PYRO_B_SENSE: J2.24 (~CE0/GPIO8); also elsewhere on the board
/Pyro Channel Pair/V_BAT: JP9.2 (C); also elsewhere on the board
/SCL: J4.4, JP4.1 (A), JP6.1 (A), JP8.1 (A), R2.1, U3.26 (SCL); also elsewhere on the board
/SCLK: J2.40 (GPIO21/SCLK1); also elsewhere on the board
/SCL_HW_0: J2.28 (ID_SC/GPIO1), JP6.2 (B)
/SCL_HW_1: J2.5 (SCL/GPIO3), JP4.2 (B)
/SCL_SW: J2.15 (GPIO22), JP8.2 (B)
/SDA: J4.3, JP3.1 (A), JP5.1 (A), JP7.1 (A), R1.1, U3.27 (SDA); also elsewhere on the board
/SDA_HW_0: J2.27 (ID_SD/GPIO0), JP5.2 (B)
/SDA_HW_1: J2.3 (SDA/GPIO2), JP3.2 (B)
/SDA_SW: J2.13 (GPIO27), JP7.2 (B)
/SHUTDOWN: J2.7 (GCLK0/GPIO4), J6.1
/XBEE_RESET: J2.11 (GPIO17), U1.5 (~RESET)
/XBEE_UART_RX: J2.8 (GPIO14/TXD), U1.3 (DIN/~CONFIG)
/XBEE_UART_TX: J2.10 (GPIO15/RXD), U1.2 (DOUT)
/XBEE_UART_~CTS: J2.19 (MOSI0/GPIO10), U1.12 (DIO7/~CTS)
/XBEE_UART_~RTS: U1.16 (DIO6/~RTS)
GND: BZ1.2 (+), C13.1, C14.1, D3.1 (K), D5.1 (K), J1.1, J2.6 (GND), J2.9 (GND), J2.14 (GND), J2.20 (GND), J2.25 (GND), J2.30 (GND), J2.34 (GND), J2.39 (GND), J3.1, J3.2, J4.1, J6.2, S0.1, S1.1, S2.1, S3.1, S4.1, S5.1, S6.1, S8.1, S9.1, S10.1, U1.10 (GND), U3.2 (A1), U3.4 (A3), U3.14 (VSS), U3.23 (~OE), U3.24 (A5); also elsewhere on the board
unnamed: D3.2 (A), R13.2
unnamed: D4.1 (RK), R18.2
unnamed: D4.2 (GK), R19.2
unnamed: D4.3 (BK), R20.2
unnamed: D5.2 (A), R21.2
unnamed: R13.1, U1.6 (DIO10/PWM0/RSSI_PWM)

Notes on the sheet:
XBee Radio
Nested Schematics
Raspberry Pi
*Note: Servo ports > S7 are +1
Connectors
PWM Expander (Servos and Pyro)

Parts:
D1, D2: BZX384-C3V3,115; D_SOD-323
J5: Screw_Terminal_01x04; TerminalBlock_Phoenix_MPT-0,5-4-2.54_1x04_P2.54mm_Horizontal
JP1: PYRO_A_SENSE_BYPASS; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP2: PYRO_B_SENSE_BYPASS; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
Q1: AO4838; SOIC-8_3.9x4.9mm_P1.27mm
R7, R8: 10k; R_0603_1608Metric
R9, R10, R11, R12: 100k; R_0603_1608Metric
R14, R15: 220; R_0603_1608Metric

Connections:
/PYRO_A: R7.1, R14.1; also elsewhere on the board
/PYRO_A_SENSE: D1.1 (K), R9.2, R10.1; also elsewhere on the board
/PYRO_B: R8.1, R15.1; also elsewhere on the board
/PYRO_B_SENSE: D2.1 (K), R11.2, R12.1; also elsewhere on the board
/Pyro Channel Pair/PYRO_A_PWR: J5.4, JP1.2 (B), Q1.7 (D), Q1.8 (D)
/Pyro Channel Pair/PYRO_B_PWR: J5.2, JP2.2 (B), Q1.5 (D), Q1.6 (D)
/Pyro Channel Pair/V_BAT: J5.1, J5.3; also elsewhere on the board
GND: D1.2 (A), D2.2 (A), Q1.1 (S), Q1.3 (S), R7.2, R8.2, R10.2, R12.2; also elsewhere on the board
unnamed: JP1.1 (A), R9.1
unnamed: JP2.1 (A), R11.1
unnamed: Q1.2 (G), R14.2
unnamed: Q1.4 (G), R15.2

Parts:
C6, C9, C10, C12: 100n; C_0603_1608Metric
C7, C15: 10n; C_0603_1608Metric
C8: 2.2n; C_0603_1608Metric
C11: 10u; C_0603_1608Metric
R16: 100k; R_0603_1608Metric
R17: 10k; R_0603_1608Metric
U4: MPL3115A2; NXP_LGA-8_3x5mm_P1.25mm_H1.1mm
U7: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U8: MCP3004; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+3V3: C6.2, C7.2, C10.2, C11.2, C15.2, U4.1 (VDD), U4.4 (VDDIO), U7.8 (VDDIO), U7.13 (VDD), U8.13 (Vref), U8.14 (Vdd); also elsewhere on the board
+BATT: R16.2; also elsewhere on the board
/MCP_CS: U8.8 (~CS/SHDN); also elsewhere on the board
/MISO: U8.10 (Dout); also elsewhere on the board
/MOSI: U8.9 (Din); also elsewhere on the board
/SCL: U4.8 (SCL), U7.23 (SCL); also elsewhere on the board
/SCLK: U8.11 (CLK); also elsewhere on the board
/SDA: U4.7 (SDL), U7.24 (SDA); also elsewhere on the board
GND: C6.1, C7.1, C8.2, C9.2, C10.1, C11.1, C12.2, C15.1, R17.1, U4.3 (GND), U7.1 (CLKIN), U7.9 (AD0), U7.11 (FSYNC), U7.18 (GND), U8.7 (DGND), U8.12 (AGND); also elsewhere on the board
unnamed: C8.1, U7.20 (CPOUT)
unnamed: C9.1, U7.10 (REGOUT)
unnamed: C12.1, U4.2 (CAP)
unnamed: R16.1, R17.2, U8.1 (CH0)

Parts:
J13: Conn_01x22_Shielded; MOLEX 22 Pin FPC 54548-2271
J14: HDMI_C_1.4; WURTH_685119136923

Connections:
/HDMI CSI Conversion/CAM_3V3: J13.1, J14.18 (+5V)
/HDMI CSI Conversion/CAM_GND: J13.4, J13.7, J13.10, J13.13, J13.16, J13.19, J13.22, J13.SH (Shield), J14.1 (D2S), J14.4 (D1S), J14.7 (D0S), J14.10 (CKS), J14.13 (GND), J14.SH
/HDMI CSI Conversion/CAM_SCL: J13.3, J14.15 (SCL)
/HDMI CSI Conversion/CAM_SDA: J13.2, J14.16 (SDA)
/HDMI CSI Conversion/D0+: J13.21, J14.2 (D2+)
/HDMI CSI Conversion/D0-: J13.20, J14.3 (D2-)
/HDMI CSI Conversion/D1+: J13.18, J14.5 (D1+)
/HDMI CSI Conversion/D1-: J13.17, J14.6 (D1-)
/HDMI CSI Conversion/DC+: J13.15, J14.8 (D0+)
/HDMI CSI Conversion/DC-: J13.14, J14.9 (D0-)
/HDMI CSI Conversion/GPIO0: J13.6, J14.11 (CK+)
/HDMI CSI Conversion/GPIO1: J13.5, J14.12 (CK-)

Parts:
C1: 10u; C_0603_1608Metric
C2, C5: 100n; C_0603_1608Metric
C3: 33pF; C_0603_1608Metric
C4: 22uF; C_0603_1608Metric
L1: 1.8uH 9.6mOhm; L_Coilcraft_XAL60xx_6.36x6.56mm
R3: 100k; R_0603_1608Metric
R4: 25.5k; R_0603_1608Metric
R5: 220k; R_0603_1608Metric
R6: 30k; R_0603_1608Metric
SW1: SW_Push; SW_PUSH_6mm
U5: TPS56424x; SOT-563

Connections:
+5V: C3.1, C4.1, C5.1, L1.2, R5.1; also elsewhere on the board
+BATT: C1.1, C2.1, SW1.1, U5.1 (VIN); also elsewhere on the board
/PWR_EN: R3.2, R4.1, U5.5 (EN); also elsewhere on the board
GND: C1.2, C2.2, C4.2, C5.2, R4.2, R6.2, U5.3 (GND), U5.4 (AGND); also elsewhere on the board
unnamed: C3.2, R5.2, R6.1, U5.6 (FB)
unnamed: L1.1, U5.2 (SW)
unnamed: R3.1, SW1.2

Board: 2 copper layers, 109.2 x 50.8 mm, 82 parts (0 on the bottom side), 76 nets.

## KiCad design Motherboard/motherboard_2022_2023/hdmi_to_csi.kicad_pcb

Parts:
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: MOLEX 22 Pin FPC 54548-2271
J2: WURTH_685119136923

Connections:
/CAM_3V3: J1.1, J2.18 (+5V)
/CAM_GND: J1.4, J1.7, J1.10, J1.13, J1.16, J1.19, J1.22, J1.SH (Shield), J2.1 (D2S), J2.4 (D1S), J2.7 (D0S), J2.10 (CKS), J2.13 (GND), J2.SH
/CAM_SCL: J1.3, J2.15 (SCL)
/CAM_SDA: J1.2, J2.16 (SDA)
/D0+: J1.21, J2.2 (D2+)
/D0-: J1.20, J2.3 (D2-)
/D1+: J1.18, J2.5 (D1+)
/D1-: J1.17, J2.6 (D1-)
/DC+: J1.15, J2.8 (D0+)
/DC-: J1.14, J2.9 (D0-)
/GPIO0: J1.6, J2.11 (CK+)
/GPIO1: J1.5, J2.12 (CK-)

Board: 2 copper layers, 29.2 x 17.1 mm, 4 parts (1 on the bottom side), 12 nets.

## Code that names these connections

File ansible/system/motherboard.dts:

// Definitions for NXP PCA9685A I2C PWM controller on ARM I2C bus.
/dts-v1/;
/plugin/;

/{
	compatible = "brcm,bcm2835";

	fragment@0 {
		target-path = "/";

		__overlay__ {
			i2c_gpio: i2c@0 {
				reg = <0xffffffff>;
				compatible = "i2c-gpio";
				// Value 0x06 is (GPIO_ACTIVE_HIGH|GPIO_OPEN_DRAIN), taken from decompiled dtbo file
				gpios = <&gpio 23 0x06 /* sda */
					 			 &gpio 24 0x06 /* scl */
					>;
				i2c-gpio,delay-us = <2>;
				#address-cells = <1>;
				#size-cells = <0>;
			};
		};
	};

	fragment@1 {
		target-path = "/aliases";
		__overlay__ {
			i2c_gpio = "/i2c@0";
		};
	};

	fragment@2 {
		target-path = "/__symbols__";
		__overlay__ {
			i2c_gpio = "/i2c@0";
		};
	};

	fragment@3 {
		target = <&i2c_gpio>;
		__overlay__ {
			#address-cells = <1>;
			#size-cells = <0>;
			status = "okay";

			pca: pca@40 {
				compatible = "nxp,pca9685-pwm";
				#pwm-cells = <2>;
				// #gpio-cells = <2>;
				reg = <0x40>;
				status = "okay";
			};
		};
	};

	fragment@4 {
		target-path = "/";
		__overlay__ {
			status_leds: leds@0 {
				compatible = "pwm-leds";
				status = "okay";

				led_g: led_g {
					label = "led_g";
					pwms = <&pca 11 20000000>;
					max-brightness = <255>;
					active-low = <1>;
				};

				led_r: led_r {
					label = "led_r";
					pwms = <&pca 12 20000000>;
					max-brightness = <255>;
					active-low = <1>;
				};

				led_b: led_b {
					label = "led_b";
					pwms = <&pca 13 20000000>;
					max-brightness = <255>;
					active-low = <1>;
				};
			};
		};
	};

	fragment@5 {
		target = <&i2c_gpio>;

		__overlay__ {
			#address-cells = <1>;
			#size-cells = <0>;
			status = "okay";
			clock-frequency = <400000>;

			mpu6050: mpu6050@68 {
				compatible = "invensense,mpu6050";
				reg = <0x68>;
				// interrupt-parent = <&gpio>;
				// interrupts = <4 2>;
			};
		};
	};

	fragment@6 {
		target-path = "/";

		__overlay__ {
			i2c_gpio_exp: i2c@4 {
				reg = <0xffffffff>;
				compatible = "i2c-gpio";
				// Value 0x06 is (GPIO_ACTIVE_HIGH|GPIO_OPEN_DRAIN), taken from decompiled dtbo file
				gpios = <&gpio 23 0x06 /* sda */
					 			 &gpio 24 0x06 /* scl */
					>;
				i2c-gpio,delay-us = <2>;
				#address-cells = <1>;
				#size-cells = <0>;
			};
		};
	};

	fragment@7 {
		target-path = "/aliases";
		__overlay__ {
			i2c_gpio_exp = "/i2c@4";
		};
	};

	fragment@8 {
		target-path = "/__symbols__";
		__overlay__ {
			i2c_gpio_exp = "/i2c@4";
		};
	};

	__overrides__ {
		i2c_gpio_sda = <&i2c_gpio>,"gpios:4";
		i2c_gpio_scl = <&i2c_gpio>,"gpios:16";
		i2c_gpio_delay_us = <&i2c_gpio>,"i2c-gpio,delay-us:0";
		i2c_bus = <&i2c_gpio>, "reg:0";

		i2c_exp_gpio_sda = <&i2c_gpio_exp>,"gpios:4";
		i2c_exp_gpio_scl = <&i2c_gpio_exp>,"gpios:16";
		i2c_exp_gpio_delay_us = <&i2c_gpio_exp>,"i2c-gpio,delay-us:0";
		i2c_exp_bus = <&i2c_gpio_exp>, "reg:0";

		pca_addr = <&pca>,"reg:0";
	};
};

## Commit log

2022-09-25 Create LICENSE
2022-09-25 Create camera_payload
    This file is still in progress and houses the majority of the camera integration/functionality code.
    Action items as of 9/25/2022:
    - Add modular methods so other parts of the program can be run (i.e. "img2BW" "applySobel")
    - Figure out how to do command line prompting to run the program so RF payload can use our program
    - Prompt program to run with "[Radio Callsign] B2 A1 C3 D4 ..."
    - Pick out and purchase microcontroller and antenna design
2022-09-27 Rename camera_payload to camera_payload.py
2022-10-18 Motherboard Project Initialized
2022-10-18 Added KiCad Gitignore
2022-10-18 Add XBee symbol
2022-10-18 Created Switching Regulator
2022-10-19 Updated Default Footprint
2022-10-19 Add XBee Footprint
2022-10-19 Added Buck and Outputs
2022-10-19 Update XBee Footprint
2022-10-19 Created MAX11600 Symbol
2022-10-19 Add 2 pyro channels
2022-10-19 Preliminary PCB layout
2022-10-20 Layout pyro channels
2022-10-22 Added Dummy Sensors
2022-10-24 Added SDA/SCL & Document Titles
2022-10-24 Added Some 5V Rails and Moved PWM Extender
2022-10-24 Adjusted IO Extender
2022-10-25 Add ansible playbook
2022-10-25 Add SAM-M8Q
2022-10-25 Nuked BNO055 & Re Laid Out Schematic
2022-10-25 New MPU6050 Symbol
2022-10-25 Add 3d models
2022-10-25 Fix pretty path
2022-10-25 New Footprint for MPU
2022-10-25 Update 3d models
2022-10-25 Added Graphics
2022-10-25 Added Logo Thing
2022-10-25 Fixed Logo Transparency
2022-10-25 Fix floods
2022-10-25 Progress on Routing Motherboard
2022-10-25 Fixed Traces to PWM Out
2022-10-25 Added Resistors to MOSFET at Ben's Request
2022-10-27 Route rest of PCB, passes almost all meaningful DRC
2022-10-27 Add 3d model for SAM-M8Q
2022-10-27 Add 3d model for XBee
2022-10-27 Add 3d model for pi zero (2?) W
2022-10-27 Fix sdr autostart
2022-10-27 Restart services only when their config changes
2022-10-28 Setup config.txt and modules-load.d with ansible
2022-10-28 Setup GPSD
2022-10-29 Datalogger with working GPSD and MPL3115 loggers
2022-10-29 Reformat Code
2022-10-30 Impliment MPU6050 logging. Also updated various things for subscale.
2022-11-01 Fixed Grammar
2022-11-05 Deploy datalogger with ansible
2022-11-11 Disable and stop packagekitd
2022-11-11 Make logger more robust gpsd messages seem to be missing parameters sometimes...
2022-11-11 Fixed Gitignore
2022-11-11 Moved Camera_Payload
2022-11-17 Add playbooks for RSMB and XBNet
2022-11-17 Add support for creating a simulated rocket with vagrant Also refactor ansible to support this
2022-11-17 Make the linter happy
2022-11-17 Simulate network performance of XBee's in vagrant
2022-11-18 Small fixes
2022-11-21 Updated Text
2022-11-22 Switch Vagrant to Debian 11 This is the version of Debian that Raspberry Pi OS is based on
2022-11-22 Increment all IPs to fix Vagrant warning Vagrant assigns the host computer 10.82.104.1, so also assigning it to the groundstation causes a lot of issues.
2022-11-24 Added Buzzer
2022-11-24 Fixed Footprint
2022-11-25 Another Buzzer Option
2022-11-26 Add option to use standalone MPU-6050 chip Also corrects a couple small bugs in footprints
2022-11-28 Add capacitors to MPL3115 according to the datasheet
2022-11-28 Add notes to schematic
2022-11-28 Connect XBee CTS to pi
2022-11-28 Add note to schematic
2022-11-28 Rounded Corners
2022-11-28 Invalid Net ID
2022-11-29 Revert "Invalid Net ID"
    This reverts commit fc0519672614838706bc989a4770002776797e12.
2022-11-29 Revert "Merge branch 'main' of https://github.com/Rose-Rocketry/NASA-USLI-2023-Electrical-Payload"
    This reverts commit 2c693e8b656697acdd5394412e94d16fb74b389e, reversing
    changes made to c3e2ab575912267e277cfde858d4ce401414edea.
2022-11-29 Revert "Rounded Corners"
    This reverts commit c3e2ab575912267e277cfde858d4ce401414edea.
2022-11-29 Tie pins high
2022-11-29 Properly Rounded Corners
2022-11-29 Add HDMI adaptor
2022-11-29 Add mousebite
2022-11-29 Final Adjustments
2022-11-29 Add caps
2022-11-29 Final Final Adjustments
2022-11-29 Moved CSI to HDMI to own PCB
2022-11-29 Updated Both PCBs
2022-11-29 Generated Gerbers
2022-11-29 Adjusted Location in Drawing
2022-11-29 Add ADC
2022-11-29 Fix XBee CTS
2022-11-29 Remove unneeded I2C pullup resistors The pi zero 2 W already has 1.8k pullups on the board
2022-11-29 Updated Gerbers
2022-11-30 Fixed Daughterboard
2022-11-30 Add XT-30 3d model
2022-11-30 Add 3d model for inductor
2022-11-30 Add piezo 3d model
2022-12-01 Add main logic README
2022-12-02 Added Buzzer Service
2022-12-05 Add power switch
2022-12-05 More robust XBee configuration (WIP)
2022-12-05 Impliment sensor daemon for cpu temperature, MPU6050, and MPL3115
2022-12-05 Uncomment virtual environment setup
2022-12-05 Added Title
2022-12-05 Added Images to Title Blocks
2022-12-05 Switch XT-30 connector for a more common type
2022-12-05 Update 3d model for new connector
2022-12-06 Update schematic footprint
2022-12-06 Removed Vestigial IMU & Added Input Breakout
2022-12-06 Neatened Connections
2022-12-06 Add STEMMA QT Connector
2022-12-06 Updated RoseRocketry Graphic
2022-12-06 Split sensor daemon into multiple, independent units
2022-12-06 Fixed Image
2022-12-06 Updated Title Block
2022-12-08 Use 64-bit build of i2c_stream
2022-12-08 Allow access to the rocket RSMB broker by any IP for easier debugging
2022-12-08 Add sensor logging and fix gpsd
2022-12-13 Added SDR mount CAD
2022-12-14 Created Step File for HDMI to CSI
2022-12-30 Added Motherboard and HDMI_to_CSI board steps
2023-01-14 Update config for full-scale payload
2023-01-16 Update system config for motherboard
2023-01-16 Add MCP3004 support to sensord for reading battery voltage
2023-01-17 Add buzzer boot and shutdown sounds
2023-01-19 Fix SDA/SCL swapped on MPU6050 and MPL3115
2023-01-19 Fix flipped FFC connector
2023-01-19 Remove unused pullup
2023-01-19 Add power-up button
2023-01-19 Use correct footprint for screw terminals
2023-01-19 Correct resistor value
2023-01-19 Update servo connector footprints
2023-01-19 Update version number
2023-01-19 Add shutdown switch
2023-01-19 Add JLCPCB order number placeholder
2023-01-20 Organize schematics
2023-01-20 Start adding selectable i2c bus to board
2023-01-20 Lots of adjustments, 3 way I2C bus selection, SMD diodes
2023-01-20 Add jumper to select pyro voltage
2023-01-21 Shrunk PCB :)
2023-01-24 Change diode footprint
2023-01-24 Change button footprint
2023-01-24 Revert "Change button footprint"
    This reverts commit 62573433dc6a31f4ca51f9e5dc16294e81f44105.
2023-01-25 Updated Version & Title Block
2023-01-28 Enable shutdown jumper
2023-01-28 Connect XBee to SPI bus
2023-01-28 Use pour for 5V bus, fixing all valid DRC errors
2023-01-28 Cleanup silkscreen
2023-01-29 Make RSSI led more informative
2023-01-29 Disconnect XBee from SPI bus (no longer needed)
2023-01-30 Tune differential pair lengths
2023-01-30 Upgrade to new version of lib_sensor_encoding
2023-01-30 Simplify rsmb.conf The old version occasionally forwarded messages to the wrong channel, probably due to a bug in rsmb.
2023-01-30 Added RGB Indicator LED and Potential Candidates
2023-01-30 Update GPIO silkscreen
2023-01-30 Traced New RGB LED
2023-01-30 Trace Fixed
2023-01-30 Simplify LED routing
2023-01-31 Update LEDs
2023-01-31 removed velocity from MPL3115 csv data
2023-01-31 Motherboard v1.1
2023-01-31 Add holes in solder mask for alignment
2023-02-08 Fixed LED
2023-02-14 Setup State Machine
2023-02-15 Various updates for new PCB revision
2023-02-15 Create a simple fake sensor daemon
2023-02-15 Change file extension for data to (more accurate) .ndjson
2023-02-16 state machine v1
2023-02-16 Add speed parameter to fake-sensord
2023-02-16 Dashboard Prototype
2023-02-16 Add --keep-timestamps option to fake sensor daemon
2023-02-16 Update state machine to load data from MQTT
2023-02-16 Move dashboard to groundstation
2023-02-17 Get all sensors up-to-date with the new board and protocol
2023-02-20 Update sensors for new data format
2023-02-20 Reduce meta packets to qos=0. qos=1 seems to cause some issues with RSMB when the groundstation side reboots...
2023-02-21 Adjust i2c config for new cable
2023-02-22 Switch to 2-cell battery
2023-02-22 Improve system graphs
2023-02-22 Switch SDR to 144.39MHz
2023-02-22 Add support to state machine for servos
2023-02-23 Rewrite logger
2023-02-24 Remove clutter from memory graph
2023-02-24 Fix buzzer
2023-02-24 Enable brightness control of RGB LED
2023-02-24 Add APRS to sensord
2023-02-24 Calibrate battery voltage
2023-03-09 Add more steps to state machine prototype
2023-03-11 Rewrite state machine to be event-driven
2023-03-12 Documentation & Readability Changes Pt. 1
2023-03-14 parser
2023-03-16 Scaffold code for handling APRS packets
2023-03-16 Use queue for events
2023-03-19 Add stub APRS parser
2023-03-19 Move state machine to sensord
2023-03-19 Fix import paths
2023-03-19 Remove infinite looping of events
2023-03-19 Add close option to pwm devices
2023-03-19 Stop and close PWM devices on exit
2023-03-19 Add service for state machine
2023-03-19 Fine-tune door code
2023-03-19 Adjust orientation code
2023-03-19 Add Parachute Deploy
2023-03-19 Close chute on exit
2023-03-19 Enable both pyro channels
2023-03-19 Initialize to launchpad state
2023-03-19 Added Notes on PCB
2023-03-19 Added git hash reporting to MQTT
2023-03-19 Print git status on state machine start
2023-03-19 Actually parse APRS commands
2023-03-23 Switch to mosquitto from RSMB
2023-03-23 Connect over xbnet
2023-03-23 Less log spam
2023-03-23 Speed up ansible
2023-03-23 Start removing ansible cruft
2023-03-23 Fine tuning based on testing
2023-03-23 Add timeout and lockout to orient
2023-03-26 Reverse door servos
2023-03-26 Increase IMU poll rate for more responsive orientation loop
2023-10-26 Updated to KiCad7
2023-10-31 Heirarchal Sheets Pin Directions Assigned
